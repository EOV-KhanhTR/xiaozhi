## xiaozhi-doremon/xiaozhi-esp32/sdkconfig.defaults.round_i80
```kconfig
CONFIG_BOARD_TYPE_ESP32S3_128_ROUND_I80=y
CONFIG_LANGUAGE_VI_VN=y
CONFIG_USE_AFE_WAKE_WORD=y
CONFIG_SEND_WAKE_WORD_DATA=y
```
